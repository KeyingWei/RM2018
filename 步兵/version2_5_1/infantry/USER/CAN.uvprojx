# Keil uVision project CAN.uvprojx, settings and files
target CAN (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CAN +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\BSP;..\Task
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c
  group my_api
    ../Task/: my_api.c DbusTask.c CanTask.c RemoteTask.c pid.c GimbalTask.c CmTask.c pid_modify.c Auto_attackTask.c
  group BSP
    ../BSP/: bsp.c led.c laser.c beep.c dbus.c usart.c timer.c pwm.c can1.c can2.c delay.c sys.c stmflash.c iwdg.c Referee.c
  group Imu
    ../BSP/: imu.c spi.c MPU6500_driver.c imu_int.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_flash.c stm32f4xx_iwdg.c stm32f4xx_exti.c
    ./: stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f427_437xx.s
